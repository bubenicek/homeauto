# IAR project TempSensor.ewp, settings and files
configuration broadcaster (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  ICC8051.CCDefines: chip=2541; WEATHER_STATION_BOARD; OFF_TX_INTERVAL; POWER_SAVING; xBDADDR_PUBLIC
  ICC8051.CCDiagSuppress: Pe001,Pa084,Pe1105
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: src; ..\components\devices\cc254x; ..\components\miniBLE; ..\components\common; ..\components\targets\TempSensor; ..\components\targets\interface
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 2
  ICC8051.IccLang: 0
  A8051.ADefines: chip=2543
  XLINK.XclFile: ti_51ew_cc2540b.xcl
  group application
    src/: config.h main.c temp_sensor.c temp_sensor.h utils.c utils.h
  group application/Drivers
    src/drivers/: ds18.c ds18.h ow.c ow.h
  group common
    ../components/common/: hal_int.c hal_types.h
  group common/8051
    ../components/common/cc8051/: hal_cc8051.h
  group devices/cc254x
    ../components/devices/cc254x/: clock.c clock.h dma.h hal_flash.h hal_mcu.c hal_sleep.h hal_timer2.c hal_timer2.h ioCC254x_bitdef.h power_mode.h power_mode.s51 prop_regs.h
  group miniBLE
    ../components/miniBLE/: miniBLE.c miniBLE.h miniBLE_defs.h miniBLE_phy.c miniBLE_phy.h miniBLE_scheduler.c miniBLE_scheduler.h
  group targets/TempSensor
    ../components/targets/TempSensor/: hal_board.h
  group targets/TempSensor/interface
    ../components/targets/interface/: hal_acc.h hal_assert.h hal_button.h hal_digio.h hal_digio2.h hal_int.h hal_lcd_sblcda4.h hal_led.h hal_lightsensor.h hal_mcu.h hal_wait.h
